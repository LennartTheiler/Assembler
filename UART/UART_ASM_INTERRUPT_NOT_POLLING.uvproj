# Keil uVision project UART_ASM_INTERRUPT_NOT_POLLING.uvproj, settings and files
target Target 1 (MCS-51)
  device: XC888CLM-8FF Infineon
  cpu: IRAM(0-0xFF) XRAM(0xF000-0xF5FF) IROM(0-0x5FFF) IROM2(0xA000-0xBFFF) CLOCK(24000000) MODP2
  output: UART_ASM_INTERRUPT_NOT_POLLING
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main_INT_NOT_POLLING.a51
